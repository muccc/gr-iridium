options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: '1621000000'
  states: {}
- name: input_filter
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, 50e3/2, 50e3/2/2, 60)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000000'
  states: {}
- name: start_finder_filter
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 250000, 10e3, 10e3, 60)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/schneider/data/iridium/raw/ppp-ethik-ascii-1621-16.cfile
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iridium_burst_downmix_0
  id: iridium_burst_downmix
  parameters:
    handle_multiple_frames_per_burst: 'False'
    hard_max_queue_len: '1000'
    input_taps: input_filter
    output_sample_rate: '250000'
    search_depth: int(0.007 * 250000)
    start_finder_taps: start_finder_filter
  states: {}
- name: iridium_fft_burst_tagger_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: 1024*8*4
    burst_pre_len: 1024*4
    burst_width: '40'
    center_frequency: center_frequency
    debug: 'False'
    fft_size: 1024*4
    history_size: '512'
    max_bursts: '0'
    sample_rate: int(samp_rate)
    threshold: '7.0'
  states: {}
- name: iridium_iridium_qpsk_demod_0
  id: iridium_iridium_qpsk_demod
  parameters:
    sample_rate: '250000'
  states: {}
- name: iridium_tagged_burst_to_pdu_0
  id: iridium_tagged_burst_to_pdu
  parameters:
    drop_overflow: 'False'
    max_burst_size: '100000'
    max_outstanding: '500'
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: This flowgraph is just an example to illustrate and test the different blocks of gr-iridium. Do not expect this one to always work ;)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    showports: 'True'
    type: msg_complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/4
    fc: '0'
    showports: 'True'
    type: msg_complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '250000'
    fc: '0'
    type: msg_complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', iridium_fft_burst_tagger_0, '0']
- [iridium_burst_downmix_0, burst_handled, iridium_tagged_burst_to_pdu_0, burst_handled]
- [iridium_burst_downmix_0, cpdus, iridium_iridium_qpsk_demod_0, cpdus]
- [iridium_burst_downmix_0, cpdus, qtgui_freq_sink_x_0, in]
- [iridium_burst_downmix_0, cpdus, qtgui_waterfall_sink_x_0_0, in]
- [iridium_fft_burst_tagger_0, '0', iridium_tagged_burst_to_pdu_0, '0']
- [iridium_fft_burst_tagger_0, '0', qtgui_freq_sink_x_0_0, '0']
- [iridium_tagged_burst_to_pdu_0, cpdus, iridium_burst_downmix_0, cpdus]
- [iridium_tagged_burst_to_pdu_0, cpdus, qtgui_waterfall_sink_x_0, in]

metadata:
  file_format: 1
