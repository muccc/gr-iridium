<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>1624800000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>input_filter</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, samp_rate, 50e3/2, 50e3/2/2, 60)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>16000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_finder_filter</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 250000, 10e3, 10e3, 60)</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/schneider/data/iridium/raw/ppp-ethik-ascii-1621-16.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>iridium_burst_downmix</key>
<param><key>id</key><value>iridium_burst_downmix_0</value></param>
<param><key>handle_multiple_frames_per_burst</key><value>False</value></param>
<param><key>hard_max_queue_len</key><value>1000</value></param>
<param><key>input_taps</key><value>input_filter</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>search_depth</key><value>int(0.007 * 250000)</value></param>
<param><key>start_finder_taps</key><value>start_finder_filter</value></param>
</block>
<block>
<key>iridium_fft_burst_tagger</key>
<param><key>id</key><value>iridium_fft_burst_tagger_0</value></param>
<param><key>burst_width</key><value>40</value></param>
<param><key>center_frequency</key><value>center_frequency</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>fft_size</key><value>1024*4</value></param>
<param><key>history_size</key><value>512</value></param>
<param><key>max_bursts</key><value>0</value></param>
<param><key>burst_post_len</key><value>1024*8*4</value></param>
<param><key>burst_pre_len</key><value>1024*4</value></param>
<param><key>sample_rate</key><value>int(samp_rate)</value></param>
<param><key>threshold</key><value>7.0</value></param>
</block>
<block>
<key>iridium_iridium_qpsk_demod</key>
<param><key>id</key><value>iridium_iridium_qpsk_demod_0</value></param>
<param><key>sample_rate</key><value>250000</value></param>
</block>
<block>
<key>iridium_tagged_burst_to_pdu</key>
<param><key>id</key><value>iridium_tagged_burst_to_pdu_0</value></param>
<param><key>drop_overflow</key><value>False</value></param>
<param><key>max_burst_size</key><value>100000</value></param>
<param><key>max_outstanding</key><value>500</value></param>
<param><key>relative_center_frequency</key><value>0.0</value></param>
<param><key>relative_sample_rate</key><value>1.0</value></param>
<param><key>relative_span</key><value>1.0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>This flowgraph is just an example to illustrate and test the different blocks of gr-iridium. Do not expect this one to always work ;)</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/4</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>250000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>iridium_fft_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iridium_burst_downmix_0</source_block_id><sink_block_id>iridium_tagged_burst_to_pdu_0</sink_block_id><source_key>burst_handled</source_key><sink_key>burst_handled</sink_key></connection>
<connection><source_block_id>iridium_burst_downmix_0</source_block_id><sink_block_id>iridium_iridium_qpsk_demod_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>iridium_burst_downmix_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>cpdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>iridium_burst_downmix_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>cpdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>iridium_fft_burst_tagger_0</source_block_id><sink_block_id>iridium_tagged_burst_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iridium_fft_burst_tagger_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iridium_tagged_burst_to_pdu_0</source_block_id><sink_block_id>iridium_burst_downmix_0</sink_block_id><source_key>cpdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>iridium_tagged_burst_to_pdu_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>cpdus</source_key><sink_key>in</sink_key></connection>
</flow_graph>
